# Keil uVision project 10-0512-001-V0.1_C51_Application.uvproj, settings and files
target 10-0512-001-V0.1_C51_Application (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: C51_App +hex
  AfterMake: AutoCopy.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Src\App\10-0512-001-V0.1_C51_Application\Drv
  link misc: REMOVEUNUSED
  group App
    ../../Src/App/10-0512-001-V0.1_C51_Application/: main.c
  group Drv
    ../../Src/App/10-0512-001-V0.1_C51_Application/Drv/: STC8G_H_ADC.c STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8G_H_Timer_Isr.c STC8G_H_UART.c STC8G_H_UART_Isr.c STC8G_H_WDT.c
