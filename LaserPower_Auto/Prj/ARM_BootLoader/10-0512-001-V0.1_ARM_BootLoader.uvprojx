# Keil uVision project 10-0512-001-V0.1_ARM_BootLoader.uvprojx, settings and files
target 10-0512-001-V0.1_ARM_BootLoader (5060960::V5.06 update 7 (build 960)::.\Compiler_5.06)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 10-0512-001-V01_ARM_BootLoader
  AfterMake: D:\Program Files\KEIL\ARM\ARM\Compiler_5.06\bin\fromelf.exe  --bin -o "10-0512-001-V0.1_ARM_BootLoader.bin" "Objects\10-0512-001-V01_ARM_BootLoader.axf"
  AfterMake: .\AutoCopy.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ../../Src/Drv/Hal/STM32F1xx_HAL_Driver/Inc;../../Src/Drv/Hal/STM32F1xx_HAL_Driver/Inc/Legacy;../../Src/Drv/Cmsis/Include;../../Src/Drv/Cmsis/Device/ST/STM32F1xx/Include;../../Src/Lib/MiddleWare/FreeRTOS/Source/portable/RVDS/ARM_CM3;../../Src/Lib/MiddleWare/FreeRTOS/Source/include;../../Src/Lib/MiddleWare/FreeRTOS/Source/CMSIS_RTOS;../../Src/Lib/MiddleWare/LwIP/src/include;../../Src/Lib/MiddleWare/LwIP/src/include/ipv4;../../Src/Lib/MiddleWare/LwIP/system;../../Src/Lib/MiddleWare/LwIP/src/include/ipv4/lwip;../../Src/Lib/MiddleWare/LwIP/src/include/lwip;../../Src/Lib/MiddleWare/LwIP/src/include/netif;../../Src/Lib/MiddleWare/LwIP/src/include/posix;../../Src/Lib/MiddleWare/LwIP/src/include/posix/sys;../../Src/Lib/MiddleWare/LwIP/src/netif/ppp;../../Src/Lib/MiddleWare/LwIP/system/arch;../../Src/Lib/UserCommon;../../Src/Drv/Bsp/10-0512-001-V0.1_ARM_BootLoader;../../Src/App/10-0512-001-V0.1_ARM_BootLoader
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Src/Drv/Cmsis
    ../../Src/Drv/Cmsis/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Src/Drv/Hal
    ../../Src/Drv/Hal/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
  group Src/Drv/Bsp
    ../../Src/Drv/Bsp/10-0512-001-V0.1_ARM_BootLoader/: BspSpi.c EthernetIf.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c
  group Src/Lib/MiddleWare/FreeRTOS
    ../../Src/Lib/MiddleWare/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../Src/Lib/MiddleWare/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../Src/Lib/MiddleWare/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Src/Lib/MiddleWare/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Src/Lib/MiddleWare/LwIP
    ../../Src/Lib/MiddleWare/LwIP/src/api/: api_msg.c err.c sockets.c netdb.c tcpip.c api_lib.c netbuf.c netifapi.c
    ../../Src/Lib/MiddleWare/LwIP/src/core/ipv4/: inet_chksum.c icmp.c ip_frag.c ip.c ip_addr.c autoip.c inet.c igmp.c
    ../../Src/Lib/MiddleWare/LwIP/src/core/: stats.c mem.c init.c netif.c pbuf.c def.c raw.c tcp_out.c dns.c tcp_in.c sys.c lwip_timers.c memp.c udp.c tcp.c dhcp.c
    ../../Src/Lib/MiddleWare/LwIP/src/netif/ppp/: ppp_oe.c chpms.c magic.c lcp.c chap.c randm.c fsm.c ppp.c md5.c ipcp.c auth.c pap.c vj.c
    ../../Src/Lib/MiddleWare/LwIP/system/OS/: sys_arch.c
    ../../Src/Lib/MiddleWare/LwIP/src/core/snmp/: asn1_dec.c msg_out.c msg_in.c mib2.c mib_structs.c asn1_enc.c
    ../../Src/Lib/MiddleWare/LwIP/src/netif/: etharp.c slipif.c
  group Src/Lib/Common
    ../../Src/Lib/UserCommon/Debug/: Debug.c
    ../../Src/Lib/UserCommon/Mem/: Mem.c MemFram.c MemSpiFlash.c MemSpiFlashIf.c MemStm32FlashIf.c
    ../../Src/Lib/UserCommon/Wdog/: Wdog.c
  group Src/App
    ../../Src/App/10-0512-001-V0.1_ARM_BootLoader/: main.c startup_stm32f107xc.s
    ../../Src/App/10-0512-001-V0.1_ARM_BootLoader/User/: Boot.c BootUart.c
